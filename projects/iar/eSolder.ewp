# IAR project eSolder.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: STM32F427VG ST STM32F427VG
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427xx
  ICCARM.CCIncludePath2: ..\..\modules; ..\..\modules\CMSIS; ..\..\modules\Core; ..\..\modules\Core\stm32f427; ..\..\modules\FreeRTOS; ..\..\modules\FreeRTOS\include; ..\..\modules\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\modules\environment
  ICCARM.CCOptLevel: 2
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: ..\..\modules\FreeRTOS
  ILINK.IlinkOutputFile: eSolder.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration STM32F427_Debug (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\..\modules; ..\..\modules\Core; ..\..\modules\Core\stm32f427; ..\..\modules\CMSIS; ..\..\modules\FreeRTOS\include; ..\..\modules\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\modules\FreeRTOS; ..\..\modules\SPL\inc
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 2
  OBJCOPY.OOCOutputFile: eSolder.srec
  ILINK.IlinkAdditionalLibs: ..\..\modules\IQ\IQmathLib-cm4.a
  group (top)
    ../../: main.c
  group Core
    ../../modules/Core/stm32f427/iar/: startup_stm32f427xx.s
    ../../modules/Core/stm32f427/: stm32f427xx.h
    ../../modules/Core/: stm32f4xx.h system_stm32f4xx.c
  group Drivers
    ../../modules/Drivers/: button.c clock.c encoders.c gpio.c gpio.h mcu.c
  group Drivers/spi
    ../../modules/Drivers/spi/: spi.c spi1.c spiPrivate.c
  group eSolder
    ../../modules/eSolder/: eSolder.c eSolder.h eSolderConstants.h
  group FreeRTOS/inc
    ../../modules/FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/src
    ../../modules/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/src/portable
    ../../modules/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group hard
    ../../modules/hard/: encoderPannel.c hard.c keyboard.c max31856mud.c thermocouples.c
  group hard/lcd
    ../../modules/hard/lcd/: ili9341.c ili9341.h ili9341_communication.h ili9341_fsmc.c ili9341_spi.c ili9341_spi_discovery.c lcd.c lcd.h lcd_backlight.c lcd_backlight.h lcd_colors.h
  group IQ
    ../../modules/IQ/: IQmathLib.h PID_GRANDO_IQ.h
  group OS
    ../../modules/OS/: mainTSK.c OS.c solderControlTsk.c soundTsk.c systemTsk.c taskPriority.h
  group Regulators
    ../../modules/Regulators/: regulatorSolder.c
  group UI
    ../../modules/UI/: UI.h UI_constants.h UI_mainWindow.c UI_private.c UI_private.h
  group UI/Fonts
    ../../modules/UI/Fonts/: Arial.c Courier_New.c DS_Digital.c DS_Digital_Small.c Fonts.h specific_symbol.c
  group UI/images
    ../../modules/UI/images/: FanFlow.c FanFlowDark.c images.h solderingDry.c solderingDryDisconnected.c solderingIron.c solderingIronDisconnected.c Thermometer.c ThermometerDark.c
