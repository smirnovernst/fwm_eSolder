# IAR project Backup of eSolder.ewp, settings and files
configuration Release (ARM)
  General.OGChipSelectEditMenu: Default None
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  ILINK.IlinkOutputFile: eSolder.out
configuration STM32F427_Debug (ARM, debug)
  as the first configuration, except:
  General.OGChipSelectEditMenu: STM32F427VG ST STM32F427VG
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32F427xx
  ICCARM.CCIncludePath2: ..\..\modules; ..\..\modules\Core; ..\..\modules\Core\stm32f427; ..\..\modules\CMSIS; ..\..\modules\FreeRTOS\include; ..\..\modules\FreeRTOS\portable\IAR\ARM_CM4F; ..\..\modules\FreeRTOS
  ICCARM.CCOptLevel: 1
  ICCARM.IccLang: 2
  AARM.AUserIncludes: ..\..\modules\FreeRTOS
  OBJCOPY.OOCOutputFile: eSolder.srec
  ILINK.IlinkAdditionalLibs: C:\Users\Ernst\Documents\Repositories\eSolder\Fwm\fwm_eSolder\modules\IQ\IQmathLib-cm4.a
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group (top)
    ../../: main.c
  group Core
    ../../modules/Core/stm32f427/iar/: startup_stm32f427xx.s
    ../../modules/Core/stm32f427/: stm32f427xx.h
    ../../modules/Core/: stm32f4xx.h system_stm32f4xx.c
  group Drivers
    ../../modules/Drivers/: mcu.c
  group FreeRTOS/inc
    ../../modules/FreeRTOS/: FreeRTOSConfig.h
  group FreeRTOS/src
    ../../modules/FreeRTOS/: croutine.c event_groups.c heap_4.c list.c queue.c stream_buffer.c tasks.c timers.c
  group FreeRTOS/src/portable
    ../../modules/FreeRTOS/portable/IAR/ARM_CM4F/: port.c portasm.s
  group hard
    ../../modules/hard/: hard.c
  group IQ
    ../../modules/IQ/: IQmathLib.h PID_GRANDO_IQ.h
  group OS
    ../../modules/OS/: OS.c
